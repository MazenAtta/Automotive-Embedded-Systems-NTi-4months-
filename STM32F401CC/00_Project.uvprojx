# Keil uVision project 00_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 00_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 03_APP
    ../Drivers/STM32F401CC/03_APP/: main.c
  group 02_SERVICES
    ../Drivers/STM32F401CC/02_SERVICES/: BIT_MATH.h STD_TYPES.h
  group 00_MCAL
    ../Drivers/STM32F401CC/00_MCAL/00_RCC/: RCC.c RCC_Cfg.c RCC.h RCC_Cfg.h RCC_Prv.h
    ../Drivers/STM32F401CC/00_MCAL/01_GPIO/: GPIO.h GPIO_Cfg.h GPIO_Prv.h GPIO.c GPIO_Cfg.c
    ../Drivers/STM32F401CC/00_MCAL/02_SYSTIC/: STK.c STK.h STK_Cfg.c STK_Cfg.h STK_Prv.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
